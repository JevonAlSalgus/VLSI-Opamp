v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmoscs.sym} 600 -200 0 1 {name=x1}
C {nmoscs2.sym} 190 -90 0 0 {name=x2}
C {pmoscs.sym} 190 -200 0 0 {name=x3}
C {pmosdiff.sym} 600 -90 0 1 {name=x4}
C {devices/lab_pin.sym} 340 -230 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 340 -210 2 0 {name=p2 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 340 -190 2 0 {name=p3 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 340 -170 2 0 {name=p4 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 340 -110 2 0 {name=p5 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 340 -90 2 0 {name=p6 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 340 -70 2 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 450 -230 0 0 {name=p8 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 450 -210 0 0 {name=p9 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 450 -190 0 0 {name=p10 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 450 -170 0 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 450 -120 0 0 {name=p12 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 450 -100 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 450 -80 0 0 {name=p14 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 450 -60 0 0 {name=p15 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 750 -120 2 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 750 -100 2 0 {name=p17 sig_type=std_logic lab=VIP}
C {devices/iopin.sym} -20 -290 2 0 {name=p18 lab=VDD}
C {devices/iopin.sym} -20 -240 2 0 {name=p19 lab=GND}
C {devices/iopin.sym} -20 -190 2 0 {name=p20 lab=RS}
C {devices/iopin.sym} -20 -140 2 0 {name=p21 lab=OUT}
C {devices/iopin.sym} -20 -90 2 0 {name=p22 lab=VIN}
C {devices/iopin.sym} -20 -40 2 0 {name=p23 lab=VIP}
